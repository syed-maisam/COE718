# Keil uVision project Media Center.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Media Center
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group audio
    ./: GLCD_SPI_LPC1700.c system_LPC17xx.c DMA.sct FLASH.ini Font_16x24_h.h Font_6x8_h.h GLCD.h KBD.h LED.h LPC17xx.h adcuser.c adcuser.h core_cm3.c core_cm3.h audio.h startup_LPC17xx.s system_LPC17xx.h type.h usb.h usbaudio.h usbaudio.uvgui.Administrator usbaudio.uvgui_Administrator.bak usbaudio.uvproj usbaudio.uvopt usbaudio_Flash.dep usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbdmain.c usbdmain.c~ usbdmain.h usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h
  group Images
    C:/Users/ECBME/Desktop/: Maisam.c
  group Flash
    ./: Blinky.build_log.htm Blinky.htm Blinky.lnp Blinky.map Blinky.plg Blinky.sct Blinky.tra Blinky_LPC1768 Flash.dep Blinky_sct.Bak ExtDll.iex adcuser.d arm_ani_16bpp.d bg_16bpp_b.d bg_16bpp_l.d bg_16bpp_r.d bg_16bpp_t.d blinky.d core_cm3.d game.d glcd_spi_lpc1700.d hehehe.d irq.d kbd.d kobe.d kobee.d
